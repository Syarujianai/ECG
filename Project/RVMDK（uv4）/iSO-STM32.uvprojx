# Keil uVision project iSO-STM32.uvprojx, settings and files
target WF-ESP8266 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Double Buffer +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\gpio;..\..\User\Common;..\..\User\ESP8266;..\..\User\Test;..\..\User\adc;..\..\User\LCD;..\..\User\sys;..\..\User\change;..\..\User\RingBuf;..\..\User\FFT;..\..\User\Rsearch;..\..\User\rtc;..\..\User\delay;..\..\FATFS;..\..\FATFS\exfuns;..\..\FATFS\MALLOC;..\..\FATFS\SD;..\..\FATFS\SPI;..\..\FATFS\src\option;..\..\FATFS\FLASH;..\..\FATFS\src;..\..\User\KEY;..\..\User\EXTI
  asm include: ..\..\DSP_Library\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group DOC
    ../../Doc/: readme.txt
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/ESP8266/: bsp_esp8266.c
    ../../User/Common/: Common.c
    ../../User/Test/: test.c
    ../../User/adc/: bsp_adc.c
    ../../User/LCD/: lcd.c
    ../../User/sys/: sys.c
    ../../User/change/: change.c
    ../../User/RingBuf/: RingBuf.c
    ../../User/FFT/: fft.c
    ../../User/Rsearch/: Rsearch.c
    ../../User/rtc/: bsp_date.c bsp_rtc.c
    ../../User/delay/: delay.c
    ../../User/EXTI/: exti.c
    ../../User/KEY/: key.c
  group FATFS
    ../../FATFS/src/: diskio.c ff.c
    ../../FATFS/src/option/: cc936.c
    ../../FATFS/exfuns/: exfuns.c
    ../../FATFS/FLASH/: flash.c
    ../../FATFS/SPI/: spi.c
    ../../FATFS/SD/: MMC_SD.C
    ../../FATFS/MALLOC/: malloc.c
software components: CMSIS:CORE 4.3.0
